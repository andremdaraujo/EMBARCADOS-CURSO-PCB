# Repository andremdaraujo/EMBARCADOS-CURSO-PCB (continued)

## KiCad design HARDWARE/KICAD/EMBARCADOS - CURSO PCB.kicad_pcb (continued)

Board: 4 copper layers, 100.0 x 82.0 mm, 171 parts (2 on the bottom side), 114 nets.

File HARDWARE/KICAD/FABRICATION/EMBARCADOS - CURSO PCB - BOM.xlsx (part):

# | Reference | Value | Datasheet | Footprint | Qty | 3D Model | MPN | Manufacturer | Notes | LCSC MANUFACTURER | LCSC MPN | LCSC Part # | Description
1 | BT1 | CR2032 | https://www.we-online.com/components/products/datasheet/7952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 | EMBARCADOS - CURSO PCB:BatteryHolder_Keystone_1060_1x2032 | 1 | https://www.we-online.com/components/products/download/79527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 | 79527141 | WURTH ELEKTRONIK | - | - | - | - | Single-cell battery
2 | C1,C3,C4,C5,C6,C9,C10,C11,C12,C14,C29,C30,C34,C35,C41,C44 | 10uF 16V | https://datasheets.kyocera-avx.com/KGM_X7R.pdf | EMBARCADOS - CURSO PCB:C_0805_2012Metric | 16 | KiCad | KGM21AR71C106K | KYOCERA/AVX | - | SAMSUNG | CL21A106KAYNNNE | C15850 | CAP 0805 10uF 16V AVX
3 | C2,C7,C8,C13,C18,C19,C20,C21,C22,C23,C24,C25,C27,C28,C31,C33,C36,C37,C38,C39,C4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 | 100nF 50V | https://datasheets.kyocera-avx.com/KGM_X7R.pdf | EMBARCADOS - CURSO PCB:C_0603_1608Metric | 24 | KiCad | KGM15BR71H104K | KYOCERA/AVX | - | YAGEO | CC0603KRX7R9BB104 | C14663 | CAP 0603 100nF 50V AVX
4 | C15 | 680nF 16V | https://datasheets.kyocera-avx.com/KGM_X7R.pdf | EMBARCADOS - CURSO PCB:C_0603_1608Metric | 1 | KiCad | KGM15BR71C684M | KYOCERA/AVX | - | YAGEO | CC0603KRX5R8BB684 | C327005 | CAP 0603 680nF 16V AVX
5 | C16,C17,C26,C32 | 10pF 50V | https://datasheets.kyocera-avx.com/C0GNP0-KGM.pdf | EMBARCADOS - CURSO PCB:C_0603_1608Metric | 4 | KiCad | KGM15ACG1H100G | KYOCERA/AVX | - | SAMSUNG | CL10C100JB8NNNC | C1634 | CAP 0603 10pF 50V AVX
6 | D1,D3,D4 | 1N5819HW | https://www.diodes.com/datasheet/download/1N5819HW.pdf | EMBARCADOS - CURSO PCB:D_SOD-123 | 3 | KiCad | 1N5819HW-7-F | DIODES INCORPORATED | - | DIODES INCORPORATED | 1N5819HW-7-F | C82544 | 40V 600mV@1A 1A SOD-323 Schottky Barrier Diodes, SOD-323
7 | D2 | NEOPIXEL | https://www.we-online.com/components/products/datasheet/1315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 | EMBARCADOS - CURSO PCB:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm | 1 | https://www.we-online.com/components/products/download/IGS_W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 | 1315050930002 | WURTH ELEKTRONIK | - | - | - | - | RGB LED with integrated controller
8 | D5 | USBLC6-2SC6 | https://www.st.com/resource/en/datasheet/usblc6-2sc6y.pdf | EMBARCADOS - CURSO PCB:SOT-23-6 | 1 |  | USBLC6-2SC6 | STMICROELECTRONICS |  | TECH PUBLIC | USBLC6-2SC6 | C2827654 | Very low capacitance ESD protection diode, 2 data-line, SOT-23-6
9 | D6 | ESDA6V1-5SC6 | https://www.st.com/resource/en/datasheet/esda6v1-5sc6.pdf | EMBARCADOS - CURSO PCB:SOT-23-6 | 1 | KiCad | ESDA6V1-5SC6 | STMICROELECTRONICS | - | TECH PUBLIC | ESDA6V1-5SC6 | C2827672 | Quintuple bidirectional transil, Suppressor for ESD protection, 6V1 Breakdown, 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
10 | D7 | RGB | https://www.we-online.com/components/products/datasheet/1505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 | EMBARCADOS - CURSO PCB:LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm | 1 | https://www.we-online.com/components/products/download/Downl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 | 150505M173300 | WURTH ELEKTRONIK | - | - | - | - | RGB LED, 6 pin package
11 | FB1,FB2,FB3,FB4 | 600R 800mA | https://www.we-online.com/components/products/datasheet/7427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 | EMBARCADOS - CURSO PCB:L_0603_1608Metric | 4 | KiCad | 742792651 | WURTH ELEKTRONIK | - | HYHONGYEX | ACMS160808A1213A | C963865 | Ferrite bead, small symbol
12 | J1,J6 | Conn_02x20_Odd_Even | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:PinSocket_2x20_P2.54mm_Horizontal | 2 | https://www.we-online.com/components/products/download/Downl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 | 613040243121 | WURTH ELEKTRONIK | THRU HOLE |  | - | - | Generic connector, double row, 02x20, odd/even pin numbering scheme (row 1 odd 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
13 | J2 | 3V-7V | https://www.we-online.com/components/products/datasheet/6941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 | EMBARCADOS - CURSO PCB:BarrelJack_GCT_DCJ200-10-A_Horizontal | 1 | https://www.we-online.com/components/products/download/Downl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 | 694108301002 | WURTH ELEKTRONIK | THRU HOLE | - | - | - | DC Barrel Jack with an internal switch
14 | J3 | USB | https://www.we-online.com/components/products/datasheet/6297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 | EMBARCADOS - CURSO PCB:USB_C_Receptacle_G-Switch_GT-USB-7010ASV | 1 | https://www.we-online.com/components/products/download/IGES_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 | 629722000214 | WURTH ELEKTRONIK | - | DEALON | USB-TYPE-C-018 | C2927038 | USB 2.0-only 16P Type-C Receptacle connector
15 | J4 | ANALOG | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:PinSocket_2x05_P2.54mm_Horizontal | 1 | https://www.we-online.com/components/products/download/Downl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 | 613010243121 | WURTH ELEKTRONIK | THRU HOLE | - | - | - | Generic connector, double row, 02x05, odd/even pin numbering scheme (row 1 odd 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
16 | J5 | Micro SD | https://www.we-online.com/components/products/datasheet/6930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 | EMBARCADOS - CURSO PCB:WE 693071020811 | 1 | https://www.we-online.com/components/products/download/Downl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 | 693071020811 | WURTH ELEKTRONIK | - | HANXIA | HX TF-CARD H1.8 SY | C19189038 | Micro SD Card Socket with one card detection pin
17 | L1 | 10uH 650mA | https://www.we-online.com/components/products/datasheet/7440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 | EMBARCADOS - CURSO PCB:WE-LQS SMT Semi-Shielded Power Inductor | 1 | https://www.we-online.com/components/products/download/WE-LQ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 | 74404024100 | WURTH ELEKTRONIK | - | CYBERMAX | CMLW252012P100MST | C520138 | IND
18 | L2 | USB 2.0 | https://www.we-online.com/components/products/datasheet/7442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 | EMBARCADOS - CURSO PCB:WE-CNSW SMT Common Mode Line Filter | 1 | https://www.we-online.com/components/products/download/WE-CN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 | 744232090 | WURTH ELEKTRONIK | - | - | - | - | IND CMC 1206 USB 2.0
19 | LED1,LED2,LED3,LED4,LED5 | RED | https://www.we-online.com/components/products/datasheet/1500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 | EMBARCADOS - CURSO PCB:LED_0603_1608Metric | 5 | KiCad | 150060SS55040 | WURTH ELEKTRONIK | - | EVERLIGHT | 19-213/R6C-AM2P1VY/3T | C128052 | Light emitting diode
20 | LS1 | 78dB 4kHz | https://www.murata.com/en-us/products/productdetail?partno=P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 | EMBARCADOS - CURSO PCB:PKM13EPYH4000-A0 | 1 | https://www.murata.com/en-us/products/productdetail?partno=P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 | PKM13EPYH4000-A0 | MURATA | THRU HOLE | - | - | - | Crystal speaker/transducer
21 | Q1,Q2,Q3 | 2N7002K | https://www.diodes.com/datasheet/download/2N7002K.pdf | EMBARCADOS - CURSO PCB:SOT-23 | 3 | KiCad | 2N7002K-7 | DIODES INCORPORATED | - | JIANGSU CHANGJING | 2N7002 | C8545 | TRANSISTOR SOT-23 MOSFET N 60V 380mA
22 | R1,R2,R8,R9,R12,R13,R14,R17,R18,R19,R20,R21,R27,R28,R29,R30,R38,R39,R40,R41,R43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 | 10K 1% | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 31 | KiCad | CRCW060310K0FK | VISHAY | - | UNI-ROYAL | 0603WAF1002T5E | C25804 | RES 0603 10K 1% VISHAY
23 | R3 | 47K 1% | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 1 | KiCad | CRCW060347K0FK | VISHAY | - | UNI-ROYAL | 0603WAF1002T5E | C25804 | RES 0603 47K 1% VISHAY
24 | R4,R5,R6,R7,R10,R22,R23,R25,R26,R33,R37,R42,R45,R46 | 51R 1% | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 14 | KiCad | CRCW060351R0FK | VISHAY | - | UNI-ROYAL | 0603WAF510JT5E | C23197 | RES 0603 51R 1% VISHAY
25 | R11,R34,R35,R36 | 1K 1% | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 4 | KiCad | CRCW06031K00FK | VISHAY | - | UNI-ROYAL | 0603WAF1001T5E | C21190 | RES 0603 1K 1% VISHAY
26 | R15,R16 | 2.2K 1% | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 2 | KiCad | CRCW06032K20FK | VISHAY | - | UNI-ROYAL | 0603WAF2201T5E | C4190 | RES 0603 2.2K 1% VISHAY
27 | R24,R31 | 5.1K 1% | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 2 | KiCad | CRCW06035K10FK | VISHAY | - | UNI-ROYAL | 0603WAF5101T5E | C23186 | RES 0603 5.1K 1% VISHAY
28 | R32 | 0R | https://www.we-online.com/components/products/datasheet/6130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 | EMBARCADOS - CURSO PCB:R_0603_1608Metric | 1 | KiCad | CRCW06030000Z0 | VISHAY | - | UNI-ROYAL | 0603WAF0000T5E | C21189 | RES 0603 0R VISHAY
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
## Commit log

2024-11-09 Adding first files; just stared component library creation.
2024-11-09 Added reference material (/DOC/ folder).
2024-11-09 Fixed doc name.
2024-11-09 Added passive components.
2024-11-10 Added more schematic symbols.
2024-11-10 Finished schematic symbols for components.
2024-11-10 Added some aux symbols.
2024-11-10 Added footprint library and included footprints available from KiCad.
2024-11-10 Added 3D model files and included them on respective footprints.
2024-11-10 Ended recordings of chapter 6. Will finish and veryfi library next.
2024-11-10 Finished library verification. Recorded bonus class about footprint wizzard.
2024-11-10 Added material about the prototype.
2024-11-12 Started schematic capture.
2024-11-12 Finished 1st pass of the power circuits. 3 classes recorded.
2024-11-14 Re-recorded class 07.03 due to audio error.
2024-11-14 Added POWER and MCU sheets. Added MCU, decoupling capacitors and crystals.
2024-11-14 Preparation for recording about labels.
2024-11-14 POWER sheet refactoring.
2024-11-15 Added IO connections to MCU; fixed MCU pins order on the library.
2024-11-15 Fixed MCU pins on schematic and routed I2C voltage translator.
2024-11-15 Refactoring.
2024-11-15 Refactoring. Added STM32XP.ioc.
2024-11-15 Recorded IO sheet class.
2024-11-15 Added ANALOG and INTERFACE sheets.
2024-11-15 Finished schematic.
2024-11-16 Refactoring of schematic. PDF plotting.
2024-11-16 Added support documents.
2024-11-16 Starting PCB layout.
2024-11-16 Did MCU positioning.
2024-11-16 Did IO positioning.
2024-11-16 Did ANALOG positioning.
2024-11-16 Did overal positioning inside the board.
2024-11-16 Finished initial positioning.
2024-11-16 Preparation for routing.
2024-11-17 Preparations for starting PCB routing.
2024-11-17 Recorded Class 08.06 Part 1.
2024-11-17 Recorded Class 08.06 Part 2.
2024-11-17 Recorded Class 08.06 Part 3.
2024-11-17 Recorded Class 08.06 Part 4.
2024-11-17 Recorded Class 08.06 Part 6.
2024-11-18 Recorded Class 08.07 Part 1.
2024-11-22 Routing detailing before Class 08.07 Part 2.
2024-11-22 Refactoring before Class 08.07 Part 3.
2024-11-22 Refactoring before Class 08.07 Part 4.
2024-11-22 Recorded Class 08.07 Part 5.
2024-11-23 Refactoring after Class 08.07 Part 5.
2024-11-23 Refactoring before Class 08.07 Part 6.
2024-11-23 Finished PCB Layout.
2024-11-24 Recorded Class 09.10.
2024-11-24 Generated Gerber and Drill files.
2024-11-24 Regenerated Gerber and Drill files.
2024-11-30 Fixed gerbers for silkscreen subtraction and added Netlist file.
2024-11-30 Created BOM.
2024-12-01 Generated BOM, Pick-And-Place and Gerber files for JLCPCB.
2024-12-01 Added JLCPCB sample BOM and CPL files.
2024-12-03 Testing PDF generation and STEP file export. Testing STEP file on Solid Edge.
2024-12-03 Removed 3D CAD folder for next classes recordings.
2024-12-05 Recorded Class 09.08. Generated PDFs for schematic and layout.
2024-12-05 Created STEP file and mechanical drawing from Solid Edge.
2025-01-05 Updated logos with higher resolution images.
2025-01-05 Added logo image files.
2025-01-05 Added QR code for project repo on GitHub. Changed board revision to 01 2025.01.05.
2025-01-05 Changed shcematic revision to 01 2025.01.05.
2025-01-05 Finished overall project review for PCB fabrication at JLCPCB.
2025-02-09 Added pictures of the manufactred boards.
2025-02-09 Revision 02: fixed minor issues with D2 and U6 symbols/footprints. Generated new gerber and Drill files. Generated new PDF files of schematic and layout.

# Repository andremdaraujo/EMBARCADOS-CURSO-PCB

File README.md:

# PROJETO DE PCB PARA SISTEMAS EMBARCADOS
  
Esta é uma placa de desenvolvimento educacional concebida como parte curso 
[**Projeto e PCB para Sistemas Embarcados**]( https://cursos.embarcados.com.br/cursos/projeto-de-pcb-para-sistemas-embarcados/). 
O curso é oferecido em parceria com o [**Portal Embarcados**](https://embarcados.com.br/).
Durante o curso, todas as etapas de projeto e desenvolvimento desta placa são mostradas, passo a passo. 
Neste repositório, é possível acessar a todos os arquivos de projeto e fabricação.

## Licença
Este é um projeto Open Source, licenciado sob a CERN-OHL-P. Mais detalhes em [LICENSE.md](./LICENSE.md).  
A placa desenvolvida durante o curso foi baseada no projeto [**STM32 Explorer Board - STM32XP**](https://github.com/MechatronixLab/STM32XP), 
que também é licenciado conforme a CERN-OHL-P e certificado pela OSWHA ([OSHW BR000018](https://certification.oshwa.org/br000018.html)).

## Especificações da placa

A placa é baseado no [**STM32F411**](https://www.st.com/en/microcontrollers-microprocessors/stm32f411.html), mais especificamente, o [**STM32F411RET6**](https://www.st.com/en/microcontrollers-microprocessors/stm32f411re.html).
Além disso, a placa apresenta alguns componentes comumente usados em sistemas embarcados, como:
- Conversores DC-DC
- Display OLED, conectado ao MCU via I²C
- LEDs RGB
- Áudio (Buzer Piezoelérico), controlada via PWM
- ADC externo com filtros antialiasing analógicos
- USB 1.1 Full Speed via conector Tipo C
- Cartão Micro SD para fácil armazenamento de dados, conectado ao MCU via SPI
- Botões conectados a pinos de entrada do MCU, além de botões para RESET e BOOT
- Vários pinos de GPIO roteados para conectores/pinos de breakout
- Bateria CR2032 para operação RTC

A placa pode ser utilizada em modo Standalone ou conectada a uma protoboard, dependendo da escolha de conectores:

## Firmware

Esta placa pode executar a aplicação de demonstração desenvolvida no projeto [STM32 Explorer Board - STM32XP](https://github.com/MechatronixLab/STM32XP).

## KiCad design HARDWARE/KICAD/EMBARCADOS - CURSO PCB.kicad_pcb

Notes on the sheet:
Revision Log: Rev: 00 - Initial Release Rev: 01 - Improved images on silkscreen Rev: 02 - Corrected minor issues on D2 and U6 symbols/footprints

Parts:
BT1: CR2032; BatteryHolder_Keystone_1060_1x2032; MPN 79527141
C1, C4, C5, C6, C9, C10, C12: 10µF 16V; C_0805_2012Metric; MPN KGM21AR71C106K; LCSC MPN CL21A106KAYNNNE
D1, D3, D4: 1N5819HW; D_SOD-123; MPN 1N5819HW-7-F; LCSC Part # C82544
FB1: 600R 800mA; L_0603_1608Metric; MPN 742792651; LCSC Part # C963865
J2: 3V-7V; BarrelJack_GCT_DCJ200-10-A_Horizontal; MPN 694108301002
JP1: BOOST OUT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: BOOST IN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 10µH 650mA; WE-LQS SMT Semi-Shielded Power Inductor; MPN 74404024100; LCSC Part # C520138
LED1, LED2, LED3, LED4, LED5: RED; LED_0603_1608Metric; MPN 150060SS55040; LCSC Part # C128052
R1, R2, R8, R9, R13, R20, R21: 10K 1%; R_0603_1608Metric; MPN CRCW060310K0FK; LCSC Part # C25804
R3: 47K 1%; R_0603_1608Metric; MPN CRCW060347K0FK; LCSC Part # C25819
U1: AP3012; SOT-23-5; MPN AP3012KTR-E1; LCSC Part # C460356
U2: LD1117S50TR; SOT-223-3_TabPin2; MPN LD1117S50TR; LCSC Part # C6187
U3: LD1117S33TR; SOT-223-3_TabPin2; MPN LD1117S33TR; LCSC Part # C6186

Connections:
+3.3V: C9.1, LED3.2 (A), U3.2 (VO); also elsewhere on the board
+3VBAT: BT1.1 (+); also elsewhere on the board
+5V: C5.1, FB1.1, LED2.2 (A), U2.2 (VO); also elsewhere on the board
+5VA: C12.1, FB1.2; also elsewhere on the board
+VBOOST: C6.1, JP1.2 (B), LED1.2 (A), U2.3 (VI); also elsewhere on the board
+VBUSF: D3.2 (A), LED4.2 (A); also elsewhere on the board
+VEXT: D4.2 (A), J2.1, LED5.2 (A); also elsewhere on the board
+VSEL: C10.1, D3.1 (K), D4.1 (K), JP2.1 (A), U3.3 (VI); also elsewhere on the board
/POWER/+3.3V LED: LED3.1 (K), R9.2
/POWER/+5V LED: LED2.1 (K), R8.2
/POWER/+VBOOST LED: LED1.1 (K), R1.2
/POWER/+VBUS LED: LED4.1 (K), R20.2
/POWER/+VEXT LED: LED5.1 (K), R21.2
/POWER/BOOST FB: R2.1, R3.2, U1.3 (FB)
/POWER/BOOST IN: C4.1, JP2.2 (B), L1.1, R13.2, U1.5 (IN)
/POWER/BOOST OUT: C1.1, D1.1 (K), JP1.1 (A), R3.1
/POWER/BOOST SW: D1.2 (A), L1.2, U1.1 (SW)
/POWER/BOOST ~SHDN: R13.1, U1.4 (~SHDN)
GND: BT1.2 (-), C1.2, C4.2, C5.2, C6.2, C9.2, C10.2, C12.2, J2.2, R1.1, R2.2, R8.1, R9.1, R20.1, R21.1, U1.2 (GND), U2.1 (GND), U3.1 (GND); also elsewhere on the board

Notes on the sheet:
BOOST OUT = 1.25 * (1 + R3/R2) +VBOOST = 7.125V

Parts:
C14, C35: 10µF 16V; C_0805_2012Metric; MPN KGM21AR71C106K; LCSC MPN CL21A106KAYNNNE
C15: 680nF 16V; C_0603_1608Metric; MPN KGM15BR71C684M; LCSC MPN CC0603KRX5R8BB684
C25, C45: 100nF 50V; C_0603_1608Metric; MPN KGM15BR71H104K; LCSC MPN CC0603KRX7R9BB104
D5: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6; LCSC Part # C2827654
FB2, FB3: 600R 800mA; L_0603_1608Metric; MPN 742792651; LCSC Part # C963865
J1, J6: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Horizontal; MPN 613040243121
J3: USB; USB_C_Receptacle_G-Switch_GT-USB-7010ASV; MPN 629722000214; LCSC Part # C2927038
J5: Micro SD; WE 693071020811; MPN 693071020811; LCSC Part # C19189038
L2: USB 2.0; WE-CNSW SMT Common Mode Line Filter; MPN 744232090
R4, R5, R6, R7, R10, R46: 51R 1%; R_0603_1608Metric; MPN CRCW060351R0FK; LCSC Part # C23197
R24, R31: 5.1K 1%; R_0603_1608Metric; MPN CRCW06035K10FK; LCSC Part # C23186
R40, R41, R47, R48: 10K 1%; R_0603_1608Metric; MPN CRCW060310K0FK; LCSC Part # C25804

Connections:
+3.3V: C35.1, C45.1, J1.1, J5.4 (VDD), J6.39, R40.1, R41.1, R47.1, R48.1; also elsewhere on the board
+5V: J1.39; also elsewhere on the board
+VBUS: C14.2, C25.1, D5.5 (VBUS), FB3.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS); also elsewhere on the board
+VBUSF: FB2.2; also elsewhere on the board
/IO/NRST CONN: J1.11, R4.2
/IO/RX CONN: J1.15, R10.2
/IO/SD DAT0: J5.7 (DAT0), R46.2
/IO/SD DAT1: J5.8 (DAT1), R47.2
/IO/SD DAT2: J5.1 (DAT2), R41.2
/IO/SWCLK CONN: J1.7, R6.2
/IO/SWDIO CONN: J1.5, R7.2
/IO/SWO CONN: J1.9, R5.2
/IO/USB CC1: J3.A5 (CC1), R31.1
/IO/USB CC2: J3.B5 (CC2), R24.1
/IO/USB DATA FLT +: D5.1 (I/O1), L2.1
/IO/USB DATA FLT -: D5.3 (I/O2), L2.4
/IO/USB DATA+: D5.6 (I/O1), J3.A6 (D+), J3.B6 (D+)
/IO/USB DATA-: D5.4 (I/O2), J3.A7 (D-), J3.B7 (D-)
/IO/VBUS T FLT: C15.2, FB2.1, FB3.2
DEBUG RX: R10.1; also elsewhere on the board
DEBUG TX: J1.13; also elsewhere on the board
GND: C14.1, C15.1, C25.2, C35.2, C45.2, D5.2 (GND), J1.2, J1.3, J1.4, J1.6, J1.8, J1.10, J1.12, J1.14, J1.16, J1.18, J1.20, J1.22, J1.24, J1.26, J1.28, J1.29, J1.30, J1.32, J1.34, J1.36, J1.38, J1.40, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J5.6 (VSS), J5.10 (SHIELD), J5.11 (SHIELD), J5.12 (SHIELD), J5.13 (SHIELD), J6.2, J6.4, J6.6, J6.8, J6.10, J6.12, J6.14, J6.16, J6.17, J6.18, J6.20, J6.22, J6.24, J6.26, J6.28, J6.30, J6.32, J6.34, J6.36, J6.37, J6.38, J6.40, R24.2, R31.2; also elsewhere on the board
I2C SCL 3.3V: J1.19; also elsewhere on the board
I2C SCL 5V: J1.33; also elsewhere on the board
I2C SDA 3.3V: J1.17; also elsewhere on the board
I2C SDA 5V: J1.31; also elsewhere on the board
NEOPIXEL DIN: J1.35; also elsewhere on the board
NEOPIXEL DOUT: J1.37; also elsewhere on the board
NRST: R4.1; also elsewhere on the board
PA0: J6.1; also elsewhere on the board
PA1: J6.3; also elsewhere on the board
PA2: J6.5; also elsewhere on the board
PA3: J6.7; also elsewhere on the board
PA4: J6.9; also elsewhere on the board
PA5: J6.11; also elsewhere on the board
PA6: J6.13; also elsewhere on the board
PA7: J6.15; also elsewhere on the board
PC0: J1.27; also elsewhere on the board
PC1: J1.25; also elsewhere on the board
PC2: J1.23; also elsewhere on the board
PC3: J1.21; also elsewhere on the board
PWM BLUE: J6.31; also elsewhere on the board
PWM BUZZER: J6.33; also elsewhere on the board
PWM GREEN: J6.29; also elsewhere on the board
PWM RED: J6.27; also elsewhere on the board
SD CARD ~IN: J5.9 (DET), R48.2; also elsewhere on the board
SPI MISO: J6.19, R46.1; also elsewhere on the board
SPI MOSI: J5.3 (CMD), J6.21; also elsewhere on the board
SPI NSS: J5.2 (DAT3/CD), J6.25, R40.2; also elsewhere on the board
SPI SCK: J5.5 (CLK), J6.23; also elsewhere on the board
SWCLK: R6.1; also elsewhere on the board
SWDIO: R7.1; also elsewhere on the board
SWO: R5.1; also elsewhere on the board
USB D+: L2.2; also elsewhere on the board
USB D-: L2.3; also elsewhere on the board
USB OTG ID: J6.35; also elsewhere on the board

Parts:
C2, C13: 100nF 50V; C_0603_1608Metric; MPN KGM15BR71H104K; LCSC MPN CC0603KRX7R9BB104
C3, C11: 10µF 16V; C_0805_2012Metric; MPN KGM21AR71C106K; LCSC MPN CL21A106KAYNNNE
D2: NEOPIXEL; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm; MPN 1315050930002
D7: RGB; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm; MPN 150505M173300
LS1: 78dB 4kHz; PKM13EPYH4000-A0; MPN PKM13EPYH4000-A0
Q1: 2N7002K; SOT-23; MPN 2N7002K-7; LCSC Part # C8545
R11: 1K 1%; R_0603_1608Metric; MPN CRCW06031K00FK; LCSC Part # C21190
R12, R17, R18, R49, R50, R51, R52, R53, R54, R55: 10K 1%; R_0603_1608Metric; MPN CRCW060310K0FK; LCSC Part # C25804
SW1: ~{RST}; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW2: BOOT; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW3: UP; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW4: LEFT; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW5: CENTER; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW6: RIGHT; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW7: BUTTON 1; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW8: BUTTON 2; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
SW9: DOWN; C&K PTS526SM20SMTR21 LFS; MPN PTS526SM20SMTR21 LFS; LCSC Part # C318884
U6: OLED 1.3" 128x64; OLED 128x64 1.3in; MPN 61300411821

Connections:
+3.3V: C11.2, C13.2, R17.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, SW2.2 (B), U6.1 (VCC); also elsewhere on the board
+5V: C2.2, D2.3 (VDD); also elsewhere on the board
+VBOOST: C3.2, LS1.1, R11.1; also elsewhere on the board
/INTERFACE/BUZZER DRAIN: LS1.2, Q1.3 (D), R11.2
BOOT0: R18.1, SW2.1 (A); also elsewhere on the board
BUTTON 1: R52.2, SW7.2 (B); also elsewhere on the board
BUTTON 2: R53.2, SW8.2 (B); also elsewhere on the board
BUTTON CENTER: R54.2, SW5.2 (B); also elsewhere on the board
BUTTON DOWN: R55.2, SW9.2 (B); also elsewhere on the board
BUTTON LEFT: R50.2, SW4.2 (B); also elsewhere on the board
BUTTON RIGHT: R51.2, SW6.2 (B); also elsewhere on the board
BUTTON UP: R49.2, SW3.2 (B); also elsewhere on the board
GND: C2.1, C3.1, C11.1, C13.1, D2.1 (VSS), D7.1 (RK), D7.3 (BK), D7.5 (GA), Q1.2 (S), R12.2, R18.2, SW1.1 (A), SW3.1 (A), SW4.1 (A), SW5.1 (A), SW6.1 (A), SW7.1 (A), SW8.1 (A), SW9.1 (A), U6.2 (GND); also elsewhere on the board
I2C SCL 3.3V: U6.3 (SCL); also elsewhere on the board
I2C SDA 3.3V: U6.4 (SDA); also elsewhere on the board
NEOPIXEL DIN: D2.2 (DIN); also elsewhere on the board
NEOPIXEL DOUT: D2.4 (DOUT); also elsewhere on the board
NRST: R17.2, SW1.2 (B); also elsewhere on the board
PWM BLUE: D7.2 (GK); also elsewhere on the board
PWM BUZZER: Q1.1 (G), R12.1; also elsewhere on the board
PWM GREEN: D7.6 (RA); also elsewhere on the board
PWM RED: D7.4 (BA); also elsewhere on the board

Parts:
C19, C20, C21, C22, C23, C31, C36, C37, C38, C39: 100nF 50V; C_0603_1608Metric; MPN KGM15BR71H104K; LCSC MPN CC0603KRX7R9BB104
C29, C30: 10µF 16V; C_0805_2012Metric; MPN KGM21AR71C106K; LCSC MPN CL21A106KAYNNNE
D6: ESDA6V1-5SC6; SOT-23-6; MPN ESDA6V1-5SC6; LCSC Part # C2827672
J4: ANALOG; PinSocket_2x05_P2.54mm_Horizontal; MPN 613010243121
R27, R28, R29, R30, R38, R39, R43, R44: 10K 1%; R_0603_1608Metric; MPN CRCW060310K0FK; LCSC Part # C25804
U4: LMV324; TSSOP-14_4.4x5mm_P0.65mm; MPN LMV324IPT; LCSC Part # C398929
U5: ADS1115; TSSOP-10_3x3mm_P0.5mm; MPN ADS1115IDGSR; LCSC Part # C37593

Connections:
+5VA: C21.2, C29.1, C30.1, C31.1, D6.5 (IO4), J4.5, U4.4 (V+), U5.8 (VDD); also elsewhere on the board
/ANALOG/AA0: C23.1, R28.2, R30.1
/ANALOG/AA0+: C22.2, R30.2, U4.3 (+)
/ANALOG/AA1: C19.1, R27.2, R29.1
/ANALOG/AA1+: C20.2, R29.2, U4.5 (+)
/ANALOG/AA2: C36.1, R38.1, R43.2
/ANALOG/AA2+: C37.2, R38.2, U4.10 (+)
/ANALOG/AA3: C39.1, R39.1, R44.2
/ANALOG/AA3+: C38.2, R39.2, U4.12 (+)
A0: D6.1 (IO1), J4.1, R28.1
A1: D6.3 (IO2), J4.3, R27.1
A2: D6.4 (IO3), J4.7, R43.1
A3: D6.6 (IO5), J4.9, R44.1
AIN0: C23.2, U4.1, U4.2 (-), U5.4 (AIN0)
AIN1: C19.2, U4.6 (-), U4.7, U5.5 (AIN1)
AIN2: C36.2, U4.8, U4.9 (-), U5.6 (AIN2)
AIN3: C39.2, U4.13 (-), U4.14, U5.7 (AIN3)
GND: C20.1, C21.1, C22.1, C29.2, C30.2, C31.2, C37.1, C38.1, D6.2 (GND), J4.2, J4.4, J4.6, J4.8, J4.10, U4.11 (V-), U5.1 (ADDR), U5.3 (GND); also elsewhere on the board
I2C SCL 5V: U5.10 (SCL); also elsewhere on the board
I2C SDA 5V: U5.9 (SDA); also elsewhere on the board

Parts:
C7, C8, C18, C24, C27, C28, C33, C40, C42, C43: 100nF 50V; C_0603_1608Metric; MPN KGM15BR71H104K; LCSC MPN CC0603KRX7R9BB104
C16, C17, C26, C32: 10pF 50V; C_0603_1608Metric; MPN KGM15ACG1H100G; LCSC MPN CL10C100JB8NNNC
C34, C41, C44: 10µF 16V; C_0805_2012Metric; MPN KGM21AR71C106K; LCSC MPN CL21A106KAYNNNE
FB4: 600R 800mA; L_0603_1608Metric; MPN 742792651; LCSC Part # C963865
Q2, Q3: 2N7002K; SOT-23; MPN 2N7002K-7; LCSC Part # C8545
R14, R19: 10K 1%; R_0603_1608Metric; MPN CRCW060310K0FK; LCSC Part # C25804
R15, R16: 2.2K 1%; R_0603_1608Metric; MPN CRCW06032K20FK; LCSC Part # C4190
R22, R23, R25, R26, R33, R37, R42, R45: 51R 1%; R_0603_1608Metric; MPN CRCW060351R0FK; LCSC Part # C23197
R32: 0R; R_0603_1608Metric; MPN CRCW06030000Z0; LCSC Part # C21189
R34, R35, R36: 1K 1%; R_0603_1608Metric; MPN CRCW06031K00FK; LCSC Part # C21190
U7: STM32F411RET6; LQFP-64_10x10mm_P0.5mm; MPN STM32F411RET6; LCSC Part # C94355
Y1: 32.768kHz 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN ABS06-32.768KHZ-T; LCSC Part # C5563819
Y2: 12MHz 18pF; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN ABM8-12.000MHZ-D2Y-T; LCSC MPN 3225 12M 18PF 20PPM

Connections:
+3.3V: C8.2, C18.2, C27.2, C40.2, C41.1, C43.2, FB4.1, Q2.1 (G), Q3.1 (G), R15.1, R16.1, U7.19 (VDD), U7.32 (VDD), U7.48 (VDD), U7.64 (VDD); also elsewhere on the board
+3.3VA: C33.2, C34.1, FB4.2, U7.13 (VDDA); also elsewhere on the board
+3VBAT: C24.2, U7.1 (VBAT); also elsewhere on the board
+5V: C7.2, R14.1, R19.1; also elsewhere on the board
+VCORE: C42.2, C44.1, U7.30 (VCAP1); also elsewhere on the board
/MCU/HSE 1: C32.2, R32.1, Y2.1
/MCU/HSE IN: C26.2, U7.5 (PH0), Y2.3
/MCU/HSE OUT: R32.2, U7.6 (PH1)
/MCU/LSE IN: C17.2, U7.3 (PC14), Y1.2
/MCU/LSE OUT: C16.2, U7.4 (PC15), Y1.1
/MCU/MCU PA15: R26.1, U7.50 (PA15)
/MCU/MCU PB6: R25.1, U7.58 (PB6)
/MCU/MCU PB8: R23.1, U7.61 (PB8)
/MCU/MCU PB9: R22.1, U7.62 (PB9)
/MCU/MCU PB12: R45.1, U7.33 (PB12)
/MCU/MCU PB13: R42.1, U7.34 (PB13)
/MCU/MCU PB15: R37.1, U7.36 (PB15)
/MCU/MCU PC6: R36.1, U7.37 (PC6)
/MCU/MCU PC7: R35.1, U7.38 (PC7)
/MCU/MCU PC8: R34.1, U7.39 (PC8)
/MCU/MCU PC9: R33.1, U7.40 (PC9)
BOOT0: U7.60 (BOOT0); also elsewhere on the board
BUTTON 1: U7.41 (PA8); also elsewhere on the board
BUTTON 2: U7.42 (PA9); also elsewhere on the board
BUTTON CENTER: U7.28 (PB2); also elsewhere on the board
BUTTON DOWN: U7.27 (PB1); also elsewhere on the board
BUTTON LEFT: U7.24 (PC4); also elsewhere on the board
BUTTON RIGHT: U7.25 (PC5); also elsewhere on the board
BUTTON UP: U7.26 (PB0); also elsewhere on the board
DEBUG RX: U7.59 (PB7); also elsewhere on the board
DEBUG TX: R25.2; also elsewhere on the board
GND: C7.1, C8.1, C16.1, C17.1, C18.1, C24.1, C26.1, C27.1, C28.1, C32.1, C33.1, C34.2, C40.1, C41.2, C42.1, C43.1, C44.2, U7.12 (VSSA), U7.18 (VSS), U7.31 (VSS), U7.47 (VSS), U7.63 (VSS), Y2.2, Y2.4; also elsewhere on the board
I2C SCL 3.3V: Q2.2 (S), R16.2, R23.2; also elsewhere on the board
I2C SCL 5V: Q2.3 (D), R14.2; also elsewhere on the board
I2C SDA 3.3V: Q3.2 (S), R15.2, R22.2; also elsewhere on the board
I2C SDA 5V: Q3.3 (D), R19.2; also elsewhere on the board
NEOPIXEL DIN: R26.2; also elsewhere on the board
NRST: C28.2, U7.7 (NRST); also elsewhere on the board
PA0: U7.14 (PA0); also elsewhere on the board
PA1: U7.15 (PA1); also elsewhere on the board
PA2: U7.16 (PA2); also elsewhere on the board
PA3: U7.17 (PA3); also elsewhere on the board
PA4: U7.20 (PA4); also elsewhere on the board
PA5: U7.21 (PA5); also elsewhere on the board
PA6: U7.22 (PA6); also elsewhere on the board
PA7: U7.23 (PA7); also elsewhere on the board
PC0: U7.8 (PC0); also elsewhere on the board
PC1: U7.9 (PC1); also elsewhere on the board
PC2: U7.10 (PC2); also elsewhere on the board
PC3: U7.11 (PC3); also elsewhere on the board
PWM BLUE: R34.2; also elsewhere on the board
PWM BUZZER: R33.2; also elsewhere on the board
PWM GREEN: R35.2; also elsewhere on the board
PWM RED: R36.2; also elsewhere on the board
SD CARD ~IN: U7.51 (PC10); also elsewhere on the board
SPI MISO: U7.35 (PB14); also elsewhere on the board
SPI MOSI: R37.2; also elsewhere on the board
SPI NSS: R45.2; also elsewhere on the board
SPI SCK: R42.2; also elsewhere on the board
SWCLK: U7.49 (PA14); also elsewhere on the board
SWDIO: U7.46 (PA13); also elsewhere on the board
SWO: U7.55 (PB3); also elsewhere on the board
USB D+: U7.45 (PA12); also elsewhere on the board
USB D-: U7.44 (PA11); also elsewhere on the board
USB OTG ID: U7.43 (PA10); also elsewhere on the board

Parts:
FID1, FID2, FID3: Fiducial; Fiducial_0.75mm_Mask1.5mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
TP1: +VBOOST; TestPoint_Keystone_5000-5004_Miniature
TP2, TP4, TP14, TP15: GND; TestPoint_Keystone_5000-5004_Miniature
TP3: +5V; TestPoint_Keystone_5000-5004_Miniature
TP5: +VSEL; TestPoint_Keystone_5000-5004_Miniature
TP6: +VEXT; TestPoint_Keystone_5000-5004_Miniature
TP7: +5VA; TestPoint_Keystone_5000-5004_Miniature
TP8: +3.3V; TestPoint_Keystone_5000-5004_Miniature
TP9: +VBUSF; TestPoint_Keystone_5000-5004_Miniature
TP10: +3VBAT; TestPoint_Keystone_5000-5004_Miniature
TP11: +VBUS; TestPoint_Keystone_5000-5004_Miniature
TP12: +3.3VA; TestPoint_Keystone_5000-5004_Miniature
TP13: +VCORE; TestPoint_Keystone_5000-5004_Miniature

Connections:
+3.3V: TP8.1; also elsewhere on the board
+3.3VA: TP12.1; also elsewhere on the board
+3VBAT: TP10.1; also elsewhere on the board
+5V: TP3.1; also elsewhere on the board
+5VA: TP7.1; also elsewhere on the board
+VBOOST: TP1.1; also elsewhere on the board
+VBUS: TP11.1; also elsewhere on the board
+VBUSF: TP9.1; also elsewhere on the board
+VCORE: TP13.1; also elsewhere on the board
+VEXT: TP6.1; also elsewhere on the board
+VSEL: TP5.1; also elsewhere on the board
GND: TP2.1, TP4.1, TP14.1, TP15.1; also elsewhere on the board

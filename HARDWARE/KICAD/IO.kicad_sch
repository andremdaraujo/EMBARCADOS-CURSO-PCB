File: HARDWARE/KICAD/IO.kicad_sch (KiCad schematic)
At the start: 25 parts, among them J2 Conn_01x20_Socket, J3 Conn_01x20_Socket, J4 USB_C_Receptacle_USB2.0_16P, J5 Micro_SD_Card_Det1, U5 USBLC6-2SC6

Commit message: Refactoring.
Connections:
- net NRST CONN: now reaches J3.6 (Pin_6), R35.2
- net SWDIO CONN: now reaches J3.3 (Pin_3), R32.2
- net SWCLK CONN: now reaches J3.4 (Pin_4), R33.2
- net SWO CONN: now reaches J3.5 (Pin_5), R34.2
- net SD DAT2: now reaches J5.1 (DAT2), R27.2
- net SD DAT0: now reaches J5.7 (DAT0), R31.2
- net USB CC1: now reaches J4.A5 (CC1), R25.1
- net USB CC2: now reaches J4.B5 (CC2), R26.1
- net SD DAT1: now reaches J5.8 (DAT1), R29.2
Other:
- company: (none) -> Mechatronix Lab
- title: (none) -> EMBARCADOS - CURSO PCB
- moved on the sheet: C24, C25, C26, C27, C28, FB3, FB4, J2, J3, J4, J5, L2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

Commit message: Added ANALOG and INTERFACE sheets.
Parts:
- C26, C27: symbol EMBARCADOS - CURSO PCB:CAP 0805 10uH 16V AVX KGM21AR71C106K -> EMBARCADOS - CURSO PCB:CAP 0805 10uF 16V AVX KGM21AR71C106K
Connections:
- net PC3: now reaches J3.11 (Pin_11)
- net PC2: now reaches J3.12 (Pin_12)
- net PC1: now reaches J3.13 (Pin_13)
- net PC0: now reaches J3.14 (Pin_14)
- net NEOPIXEL DOUT: now reaches J3.19 (Pin_19)
Other:
- note removed: "BOTÃO BOOT0"
Changed lines of the file:
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@@
 	(wire
 		(pts
+			(xy 157.48 137.16) (xy 187.96 137.16)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 185.42 77.47) (xy 204.47 77.47)
 		)
@@
 	(wire
 		(pts
+			(xy 157.48 142.24) (xy 187.96 142.24)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 96.52 124.46) (xy 88.9 124.46)
 		)
@@
 	(wire
 		(pts
+			(xy 157.48 134.62) (xy 187.96 134.62)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 104.14 55.88) (xy 105.41 55.88)
 		)
@@
 	(wire
 		(pts
+			(xy 157.48 139.7) (xy 187.96 139.7)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 110.49 26.67) (xy 118.11 26.67)
 		)
@@
 	(wire
 		(pts
+			(xy 157.48 154.94) (xy 187.96 154.94)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 170.18 116.84) (xy 187.96 116.84)
 		)
@@
 		)
 	)
-	(text "BOTÃO BOOT0\n"
-		(exclude_from_sim no)
-		(at 233.68 132.08 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-				(thickness 0.254)
-				(bold yes)
-				(color 255 0 0 1)
-			)
-		)
-	)
 	(label "SWCLK CONN"
 		(at 184.15 116.84 180)
@@
 		)
 	)
-	(global_label "BOOT0"
-		(shape input)
-		(at 228.6 127 0)
+	(global_label "USB D+"
+		(shape bidirectional)
+		(at 119.38 59.69 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 237.6933 127 0)
+			(at 131.0965 59.69 0)
 			(effects
 				(font
@@
 		)
 	)
-	(global_label "USB D+"
-		(shape bidirectional)
-		(at 119.38 59.69 0)
+	(global_label "NEOPIXEL DOUT"
+		(shape input)
+		(at 157.48 154.94 180)
 		(fields_autoplaced yes)
 		(effects
@@
 				(size 1.27 1.27)
 			)
-			(justify left)
+			(justify right)
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 131.0965 59.69 0)
+			(at 139.5572 154.94 0)
 			(effects
 				(font
 					(size 1.27 1.27)
 				)
-				(justify left)
+				(justify right)
 				(hide yes)
 			)
@@
 		)
 	)
+	(global_label "PC2"
+		(shape bidirectional)
+		(at 157.48 137.16 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 149.634 137.16 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "I2C SCL 5V"
 		(shape input)
@@
 		)
 	)
+	(global_label "PC3"
+		(shape bidirectional)
+		(at 157.48 134.62 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 149.634 134.62 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "PA7"
 		(shape output)
@@
 		)
 	)
+	(global_label "PC1"
+		(shape bidirectional)
+		(at 157.48 139.7 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 149.634 139.7 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "PWM BLUE"
 		(shape output)
@@
 		)
 	)
+	(global_label "PC0"
+		(shape bidirectional)
+		(at 157.48 142.24 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 149.634 142.24 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "PWM RED"
 		(shape output)
@@
 	)
 	(symbol
-		(lib_id "EMBARCADOS - CURSO PCB:CAP 0805 10uH 16V AVX KGM21AR71C106K")
+		(lib_id "EMBARCADOS - CURSO PCB:CAP 0805 10uF 16V AVX KGM21AR71C106K")
 		(at 224.79 26.67 90)
 		(unit 1)
@@
 			)
 		)
-		(property "Description" "CAP 0805 10uH 16V AVX"
+		(property "Description" "CAP 0805 10uF 16V AVX"
 			(at 234.188 26.67 0)
 			(effects
@@
 	)
 	(symbol
-		(lib_id "EMBARCADOS - CURSO PCB:CAP 0805 10uH 16V AVX KGM21AR71C106K")
+		(lib_id "EMBARCADOS - CURSO PCB:CAP 0805 10uF 16V AVX KGM21AR71C106K")
 		(at 83.82 26.67 90)
 		(unit 1)
@@
 			)
 		)
-		(property "Description" "CAP 0805 10uH 16V AVX"
+		(property "Description" "CAP 0805 10uF 16V AVX"
 			(at 93.218 26.67 0)
 			(effects

Commit message: Refactoring.
Connections:
- net RX CONN: now reaches J3.8 (Pin_8), R36.2
- net VBUS T FLT: now reaches C24.2, FB3.2, FB4.1
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 116.84 59.69) (xy 119.38 59.69)
+			(xy 116.84 59.69) (xy 130.81 59.69)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 110.49 26.67) (xy 118.11 26.67)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 115.57 104.14) (xy 115.57 157.48)
 		)
@@
 	(wire
 		(pts
-			(xy 110.49 26.67) (xy 118.11 26.67)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 196.85 69.85) (xy 220.98 69.85)
 		)
@@
 	(wire
 		(pts
-			(xy 116.84 57.15) (xy 119.38 57.15)
+			(xy 116.84 57.15) (xy 130.81 57.15)
 		)
 		(stroke
@@
 		)
 	)
+	(label "VBUS T FLT"
+		(at 116.84 26.67 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 0.635 0.635)
+			)
+			(justify right bottom)
+		)
+	)
 	(label "SWDIO CONN"
 		(at 184.15 114.3 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 0.635 0.635)
+			)
+			(justify right bottom)
+		)
+	)
+	(label "RX CONN"
+		(at 184.15 127 180)
 		(fields_autoplaced yes)
 		(effects
@@
 	(global_label "USB D+"
 		(shape bidirectional)
-		(at 119.38 59.69 0)
+		(at 130.81 59.69 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 131.0965 59.69 0)
+			(at 142.5265 59.69 0)
 			(effects
 				(font
@@
 	(global_label "USB D-"
 		(shape bidirectional)
-		(at 119.38 57.15 0)
+		(at 130.81 57.15 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 131.0965 57.15 0)
-			(effects
-				(font
+			(at 142.5265 57.15 0)
+			(effects
+				(font

Commit message: Refactoring.
Other:
- moved on the sheet: J2, J3, R32, R33, R34, R35, R36

Commit message: Did IO positioning.
Connections:
- net USB D+: now also L2.2; no longer L2.3
- net USB D-: now also L2.3; no longer L2.2
- net USB DATA FLT +: now also L2.1; no longer L2.4
- net USB DATA FLT -: now also L2.4; no longer L2.1
Changed lines of the file:
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@@
 		(lib_id "EMBARCADOS - CURSO PCB:IND CMC 1206 USB 2.0 WÜRTH ELEKTRONIK 744232090 ")
 		(at 110.49 58.42 0)
+		(mirror x)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "L2"
-			(at 110.49 53.34 0)
+			(at 110.49 63.5 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "USB 2.0"
-			(at 110.109 53.34 0)
+			(at 110.109 63.5 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "https://www.we-online.com/components/products/datasheet/744232090.pdf"
-			(at 111.506 69.596 0)
+			(at 111.506 47.244 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "IND CMC 1206 USB 2.0"
-			(at 110.744 72.898 0)
+			(at 110.744 43.942 0)
 			(effects
 				(font
@@
 		)
 		(property "MPN" "744232090 "
-			(at 110.49 66.04 0)
+			(at 110.49 50.8 0)
 			(effects
 				(font
@@
 		)
 		(property "Manufacturer" "WÜRTH ELEKTRONIK "
-			(at 110.49 63.5 0)
+			(at 110.49 53.34 0)
 			(effects
 				(font
@@
 		)
 		(property "3D Model" "https://www.we-online.com/components/products/download/WE-CNSW_1206_CNSW%20%28rev1%29.igs"
-			(at 111.506 69.596 0)
+			(at 111.506 47.244 0)
 			(effects
 				(font
@@
 		)
 		(property "Notes" "-"
-			(at 110.236 83.82 0)
+			(at 110.236 33.02 0)
 			(effects
 				(font
@@
 		)
 		(property "LCSC Part # " "-"
-			(at 109.982 84.328 0)
+			(at 109.982 32.512 0)
 			(effects
 				(font
@@
 		)
 		(property "LCSC MPN " "-"
-			(at 110.744 83.312 0)
+			(at 110.744 33.528 0)
 			(effects
 				(font
@@
 		)
 		(property "LCSC MANUFACTURER " "-"
-			(at 110.744 85.598 0)
+			(at 110.744 31.242 0)
 			(effects
 				(font

Commit message: Did ANALOG positioning.
Connections:
- net USB D+: no longer L2.2
- net USB D-: no longer L2.3
- net USB DATA FLT +: no longer L2.1
- net USB DATA FLT -: no longer L2.4
Other:
- moved on the sheet: L2
Changed lines of the file:
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@@
 	(symbol
 		(lib_id "EMBARCADOS - CURSO PCB:IND CMC 1206 USB 2.0 WÜRTH ELEKTRONIK 744232090 ")
-		(at 110.49 58.42 0)
+		(at 110.49 49.53 0)
 		(mirror x)
 		(unit 1)
@@
 		(dnp no)
 		(property "Reference" "L2"
-			(at 110.49 63.5 0)
+			(at 110.49 54.61 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "USB 2.0"
-			(at 110.109 63.5 0)
+			(at 110.109 54.61 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "EMBARCADOS - CURSO PCB:WE-CNSW SMT Common Mode Line Filter"
-			(at 110.49 58.42 0)
+			(at 110.49 49.53 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "https://www.we-online.com/components/products/datasheet/744232090.pdf"
-			(at 111.506 47.244 0)
+			(at 111.506 38.354 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "IND CMC 1206 USB 2.0"
-			(at 110.744 43.942 0)
+			(at 110.744 35.052 0)
 			(effects
 				(font
@@
 		)
 		(property "MPN" "744232090 "
-			(at 110.49 50.8 0)
+			(at 110.49 41.91 0)
 			(effects
 				(font
@@
 		)
 		(property "Manufacturer" "WÜRTH ELEKTRONIK "
-			(at 110.49 53.34 0)
+			(at 110.49 44.45 0)
 			(effects
 				(font
@@
 		)
 		(property "3D Model" "https://www.we-online.com/components/products/download/WE-CNSW_1206_CNSW%20%28rev1%29.igs"
-			(at 111.506 47.244 0)
+			(at 111.506 38.354 0)
 			(effects
 				(font
@@
 		)
 		(property "Notes" "-"
-			(at 110.236 33.02 0)
+			(at 110.236 24.13 0)
 			(effects
 				(font
@@
 		)
 		(property "LCSC Part # " "-"
-			(at 109.982 32.512 0)
+			(at 109.982 23.622 0)
 			(effects
 				(font
@@
 		)
 		(property "LCSC MPN " "-"
-			(at 110.744 33.528 0)
+			(at 110.744 24.638 0)
 			(effects
 				(font
@@
 		)
 		(property "LCSC MANUFACTURER " "-"
-			(at 110.744 31.242 0)
+			(at 110.744 22.352 0)
 			(effects
 				(font

Commit message: Recorded Class 08.06 Part 1.
Parts:
- removed J2, J3: Conn_01x20_Socket, EMBARCADOS - CURSO PCB:PinSocket_1x20_P2.54mm_Horizontal, symbol EMBARCADOS - CURSO PCB:CONN 2.54mm 01x20 90° WÜRTH ELEKTRONIK 613020143121
- added J2, J3: Conn_02x20_Odd_Even, EMBARCADOS - CURSO PCB:PinSocket_2x20_P2.54mm_Horizontal, symbol EMBARCADOS - CURSO PCB:CONN 2.54mm 02x20 90° WÜRTH ELEKTRONIK 613040243121
Connections:
- net +3.3V: now also J2.1 (Pin_1), J3.39 (Pin_39)
- net +5V: now also J2.39 (Pin_39)
- net DEBUG TX: now also J2.13 (Pin_13)
- net GND: now also J2.10 (Pin_10), J2.12 (Pin_12), J2.14 (Pin_14), J2.16 (Pin_16), J2.18 (Pin_18), J2.2 (Pin_2), J2.20 (Pin_20), J2.22 (Pin_22), J2.24 (Pin_24), J2.26 (Pin_26), J2.28 (Pin_28), J2.29 (Pin_29)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
- net I2C SCL 3.3V: now also J2.19 (Pin_19)
- net I2C SCL 5V: now also J2.33 (Pin_33)
- net I2C SDA 3.3V: now also J2.17 (Pin_17)
- net I2C SDA 5V: now also J2.31 (Pin_31)
- net NEOPIXEL DIN: now also J2.35 (Pin_35)
- net NEOPIXEL DOUT: now also J2.37 (Pin_37)
- net NRST CONN: now also J2.11 (Pin_11)
- net PA0: now also J3.1 (Pin_1)
- net PA1: now also J3.3 (Pin_3)
- net PA2: now also J3.5 (Pin_5)
- net PA3: now also J3.7 (Pin_7)
- net PA4: now also J3.9 (Pin_9)
- net PA5: now also J3.11 (Pin_11)
- net PA6: now also J3.13 (Pin_13)
- net PA7: now also J3.15 (Pin_15)
- net PC0: now also J2.27 (Pin_27)
- net PC1: now also J2.25 (Pin_25)
- net PC2: now also J2.23 (Pin_23)
- net PC3: now also J2.21 (Pin_21)
- net PWM BLUE: now also J3.31 (Pin_31)
- net PWM BUZZER: now also J3.33 (Pin_33)
- net PWM GREEN: now also J3.29 (Pin_29)
- net PWM RED: now also J3.27 (Pin_27)
- net RX CONN: now also J2.15 (Pin_15)
- net SPI MISO: now also J3.19 (Pin_19)
- net SPI MOSI: now also J3.21 (Pin_21)
- net SPI NSS: now also J3.25 (Pin_25)
- net SPI SCK: now also J3.23 (Pin_23)
- net SWCLK CONN: now also J2.7 (Pin_7)
- net SWDIO CONN: now also J2.5 (Pin_5)
- net SWO CONN: now also J2.9 (Pin_9)
- net USB D+: now also L2.2
- net USB D-: now also L2.3
- net USB DATA FLT +: now also L2.1
- net USB DATA FLT -: now also L2.4
- net USB OTG ID: now also J3.35 (Pin_35)
Other:
- moved on the sheet: L2
